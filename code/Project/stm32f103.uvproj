# Keil uVision project stm32f103.uvproj, settings and files
target STM32F103 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\..\Source\core;.\..\Source\fwlib\inc;.\..\Source\hardware\inc;.\..\Source\UCOSII\CONFIG;.\..\Source\UCOSII\PORT;.\..\Source\UCOSII\CORE;.\..\Source\user;.\..\Source\NET\device\inc;.\..\Source\NET\protocol\inc;.\..\Source\fwlib\src;.\..\Source\hardware\src;.\..\Source\include;.\..\Source\App;.\..\Source\core\startup\arm
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../Source/core/: core_cm3.c system_stm32f10x.c
    ../Source/core/startup/arm/: startup_stm32f10x_md.s
  group ucos_CORE
    ../Source/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos_PORT
    ../Source/UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group ucos_CONFIG
    ../Source/UCOSII/CONFIG/: includes.h os_cfg.h
  group fwlib
    ../Source/fwlib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group hardware
    ../Source/user/: MyOthers.c
    ../Source/hardware/src/: delay.c led.c
  group user
    ../Source/user/: main.c Zigbee.c Flash.c MyIO.c MyQueue.c UserInterface.c MyIOData.c
  group includes
    ../Source/include/: app_cfg.h
    ../Source/core/: core_cm3.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.h
    ../Source/user/: UserInterface.h MyIO.h
  group App
    ../Source/App/: app.c
    ../Source/user/: Zigbee.c
